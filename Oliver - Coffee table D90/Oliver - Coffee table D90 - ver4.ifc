Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Oliver - Coffee table D90 - ver4.ifc
Time: 2024-01-12T10:59:22
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (14)
Name
 | Oliver - Coffee table D90 model_0 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_1 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_2 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_3 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_4 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_5 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_6 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_7 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_8 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_9 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_10 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_11 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_12 - ObjectType: SketchupGroup
 | Oliver - Coffee table D90 model_13 - ObjectType: SketchupGroup
